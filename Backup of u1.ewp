# IAR project Backup of u1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: u1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: stm8/inc; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: u1.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c stm8s_it.c
  group common
    common/: hw_uart.c pwr.c str1.c str2.c timer.c uart.c wdt.c
  group common/hw
    common/hw/: hw.c hw_out.c
  group cp
    cp/: hw_inp.c
  group stm8
    stm8/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
